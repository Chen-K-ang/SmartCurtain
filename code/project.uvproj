# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: main.c 24C02C.c delay.c I2C.c DS1302.c LCD1602.c motor.c key.c
